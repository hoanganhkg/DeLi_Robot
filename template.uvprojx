# Keil uVision project template.uvprojx, settings and files
target DELI_ROBOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\fileTV;.\fileTV\PWM;.\fileTV\CAN;.\src;.\fileTV\ENC;.\fileTV\Timer;.\fileTV\INC;.\fileTV\inputcapture;.\fileTV\INPP;.\fileTV\UART;.\fileTV\TEST;.\fileTV\IMU1;.\fileTV\IMU_RTxQ;.\fileTV\RTC;.\fileTV\Watchdog_timer;.\fileTV\BNO055
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c main.c utils.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
  group startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_iwdg.c
  group fileTV
    ./fileTV/PWM/: UGV_PWM.c
    ./fileTV/UART/: UART.c
    ./fileTV/CAN/: UGV_CAN.c
    ./fileTV/Timer/: UGV_Timer.c
    ./fileTV/inputcapture/: inputcapture.c
    ./fileTV/IMU1/: HMC5883L.c MPU6050.c IMU.c
    ./fileTV/IMU_RTxQ/: IMU_RTxQ.c
    ./fileTV/ENC/: UGV_ENC.c
    ./fileTV/RTC/: RTC.c
    ./fileTV/Watchdog_timer/: UGV_Watchdog_timer.c
    ./fileTV/BNO055/: BNO055.c
